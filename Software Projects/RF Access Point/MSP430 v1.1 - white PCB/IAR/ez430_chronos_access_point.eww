<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ez430_chronos_access_point.ewp</path>
  </project>
  <batchBuild/>
</workspace>


